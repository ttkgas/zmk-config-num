## boards/shields/jigglep/Kconfig.defconfig
```kconfig
if SHIELD_JIGGLEP

config ZMK_KEYBOARD_NAME
    default "jigglep"
ZMK_USB=y
endif
```
